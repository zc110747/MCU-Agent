# Keil uVision project stm32h743.uvprojx, settings and files
target Debug (6140000::V6.14::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: nes_h743 +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32H743xx,USE_HAL_DRIVER,HSE_VALUE=25000000,CFG_TUSB_MCU=OPT_MCU_STM32H7,CFG_TUSB_OS=OPT_OS_NONE
  c include: ../Core/Inc;../app;../bsp;../Drivers/CMSIS/Include;../Drivers/CMSIS/Core/Include;../sys_startup;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../third_party/FatFs;../third_party/lvgl;../third_party/lvgl/src;../third_party/nes;../third_party/tinyusb/src;../third_party/tjpgd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\STM32H743ZITX.sct
  group Startup
    ../sys_startup/: system_stm32h7xx.c
    ../sys_startup/arm/: startup_stm32h743xx.s
  group Application/Core
    ../Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
    ./: mdk_target.c
  group Board Support (bsp)
    ../bsp/: drv_spi_oled.c drv_oled_fonts.c drv_oled_text.c drv_sdio.c drv_rtc.c disk_interface.c sram_pool.c jpeg_enc.c screen_cap.c lv_port_disp.c lv_font_gbk.c lv_gbk_map.c bsp_console.c bsp_key.c drv_usb_cdc.c usb_descriptors.c gbk_conv.c gbk_unicode_tbl.c drv_camera_ov5640.c drv_camera.c bsp_log.c
  group Application (app)
    ../app/: app_main.c app_menu.c app_pages.c menu_icons.c sd_browser.c page_nes.c img_decode.c page_image.c page_txt.c page_camera.c app_cmd.c ui_font.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sd.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group ThirdParty/LVGL
    ../third_party/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../third_party/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../third_party/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../third_party/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../third_party/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../third_party/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../third_party/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../third_party/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../third_party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../third_party/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../third_party/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../third_party/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../third_party/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../third_party/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../third_party/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../third_party/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../third_party/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../third_party/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../third_party/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../third_party/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../third_party/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../third_party/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../third_party/lvgl/src/extra/: lv_extra.c
    ../third_party/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../third_party/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../third_party/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../third_party/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../third_party/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../third_party/lvgl/src/extra/others/msg/: lv_msg.c
    ../third_party/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../third_party/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../third_party/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../third_party/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../third_party/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../third_party/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../third_party/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../third_party/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../third_party/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../third_party/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../third_party/lvgl/src/extra/widgets/led/: lv_led.c
    ../third_party/lvgl/src/extra/widgets/list/: lv_list.c
    ../third_party/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../third_party/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../third_party/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../third_party/lvgl/src/extra/widgets/span/: lv_span.c
    ../third_party/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../third_party/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../third_party/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../third_party/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../third_party/lvgl/src/extra/widgets/win/: lv_win.c
    ../third_party/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../third_party/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../third_party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../third_party/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group ThirdParty/TinyUSB
    ../third_party/tinyusb/src/: tusb.c
    ../third_party/tinyusb/src/common/: tusb_fifo.c
    ../third_party/tinyusb/src/device/: usbd.c
    ../third_party/tinyusb/src/class/cdc/: cdc_device.c
    ../third_party/tinyusb/src/portable/synopsys/dwc2/: dcd_dwc2.c dwc2_common.c
  group ThirdParty/NES
    ../third_party/nes/: nes_cpu.c nes_ppu.c nes_bus.c nes_mapper.c nes_main.c
  group ThirdParty/TJpgDec
    ../third_party/tjpgd/: tjpgd.c
  group ThirdParty/FatFs
    ../third_party/FatFs/: diskio.c ff.c ffsystem.c ffunicode.c
target Release (6140000::V6.14::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: as above
  output: nes_h743 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
