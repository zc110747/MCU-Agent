# Keil uVision project stm32h743.uvprojx, settings and files
target stm32h743 (6140000::V6.14::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: stm32h743 +hex
  AfterMake: fromelf --bin !L --output Objects\stm32h743.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32H743xx,USE_HAL_DRIVER,USE_PWR_LDO_SUPPLY,CFG_TUSB_MCU=OPT_MCU_STM32H7,CFG_TUSB_OS=1,BOARD_TUD_RHPORT=0,USB_PORT_IS_FS=1
  c include: ..\app;..\app\usb;..\bsp;..\Drivers\CMSIS\Core\Include;..\Drivers\CMSIS\Include;..\sys_startup;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\third_party\tinyusb\src;..\third_party\FatFs
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/Startup
    ../sys_startup/: system_stm32h7xx.c
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../app/: main.c stm32h7xx_it.c
    ../bsp/: bsp.c bsp_led.c bsp_log.c bsp_sdcard.c bsp_sdcache.c
    ../app/usb/: usb_descriptors.c msc_disk.c sd_app.c disk_interface.c
    ./: mdk_target.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_sd.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_dma.c
  group Middlewares/TinyUSB
    ../third_party/tinyusb/src/: tusb.c
    ../third_party/tinyusb/src/common/: tusb_fifo.c
    ../third_party/tinyusb/src/device/: usbd.c
    ../third_party/tinyusb/src/class/cdc/: cdc_device.c
    ../third_party/tinyusb/src/class/msc/: msc_device.c
    ../third_party/tinyusb/src/portable/synopsys/dwc2/: dcd_dwc2.c dwc2_common.c
  group Middlewares/FatFs
    ../third_party/FatFs/: diskio.c ff.c ffsystem.c ffunicode.c
