# Keil uVision project stm32f429_net.uvprojx, settings and files
target stm32f429_net (6160000::V6.16::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CLOCK(25000000) CPUTYPE("Cortex-M4") ELITTLE FPU2
  output: stm32f429_net +hex
  AfterMake: fromelf --bin !L --output .\Objects\stm32f429_net.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F429xx,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>
  c include: ..\app;..\app\lwip;..\app\web;..\app\snmp;..\bsp;..\sys_startup;..\Drivers\CMSIS\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\third_party\LwIP\src\include;..\third_party\LwIP\system\arch;..\third_party\FreeRTOS-Kernel\include;..\third_party\FreeRTOS-Kernel\portable\GCC\ARM_CM4F;..\third_party\mbedtls\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f429_net.sct
  group Startup/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../app/: freertos_hooks.c hwinfo.c log.c main.c mbedtls_pool.c netcfg.c sdram_heap.c shell.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c telnet_shell.c
  group Application/User/LwIP
    ../app/lwip/: ethernetif.c lan8720.c lwip.c sys_arch.c
  group Application/User/Web
    ../app/web/: http_server.c https_server.c web_assets.c web_serve.c
  group Application/User/SNMP
    ../app/snmp/: ber.c mib.c snmp_agent.c snmp_msg.c
  group Drivers/BSP
    ../bsp/: bsp_ap3216.c bsp_eeprom_24c02.c bsp_i2c.c bsp_led.c bsp_mpu9250.c bsp_pcf8574.c bsp_sdram.c bsp_uart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_eth.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../sys_startup/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../third_party/FreeRTOS-Kernel/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
    ../third_party/FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c
    ../third_party/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
  group Middlewares/LwIP
    ../third_party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netifapi.c tcpip.c
    ../third_party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../third_party/LwIP/src/core/ipv4/: ip4.c ip4_addr.c ip4_frag.c autoip.c dhcp.c etharp.c icmp.c igmp.c
    ../third_party/LwIP/src/netif/: ethernet.c
  group Middlewares/mbedTLS
    ../third_party/mbedtls/library/: aes.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.c bignum_mod.c bignum_mod_raw.c block_cipher.c cipher.c cipher_wrap.c constant_time.c ecdh.c ecdsa.c ecp.c ecp_curves.c error.c gcm.c md.c memory_buffer_alloc.c oid.c pem.c pk.c pk_ecc.c pk_wrap.c pkparse.c platform.c platform_util.c sha1.c sha256.c ssl_ciphersuites.c ssl_msg.c ssl_tls.c ssl_tls12_server.c x509.c x509_crt.c
