# Keil uVision project stm32h743.uvprojx, settings and files
target stm32h743 (6140000::V6.14::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: stm32h743 +hex
  AfterMake: fromelf --bincombined --output Objects\stm32h743.bin !L
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=5 wLevel=1
  c define: STM32H743xx,USE_HAL_DRIVER,CORE_CM7,CFG_TUSB_MCU=OPT_MCU_STM32H7,CFG_TUSB_OS=OPT_OS_NONE,BOARD_TUD_RHPORT=0
  c misc: -Wno-unused-parameter -Wno-sign-compare -fno-strict-aliasing
  c include: ..\app;..\bsp;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\sys_startup;..\Drivers\CMSIS\Include;..\third_party\tinyusb\src;..\third_party\FatFs;..\third_party\hmac_sha256;..\third_party\mini_json
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: stm32h743.sct
  link misc: --diag_suppress=L6314W
  group Application/Startup
    ../sys_startup/: system_stm32h7xx.c
    ./: startup_stm32h743xx.s
  group Application/User
    ../app/: main.c stm32h7xx_it.c
    ./: mdk_target.c
  group Application/Boot
    ../app/: boot.c upgrade.c fs_init.c
  group Bsp
    ../bsp/: bsp_log.c uart.c led.c mpu.c qspi.c msc_qspi.c flash_upgrade.c disk_interface.c fs_qspi.c usb_board.c usb_desc.c
  group Middlewares/FatFs
    ../third_party/FatFs/: diskio.c ff.c ffsystem.c ffunicode.c
  group Middlewares/TinyUSB
    ../third_party/tinyusb/src/: tusb.c
    ../third_party/tinyusb/src/common/: tusb_fifo.c
    ../third_party/tinyusb/src/device/: usbd.c
    ../third_party/tinyusb/src/class/msc/: msc_device.c
    ../third_party/tinyusb/src/portable/synopsys/dwc2/: dcd_dwc2.c dwc2_common.c
  group Middlewares/hmac_sha256
    ../third_party/hmac_sha256/: sha256.c hmac_sha256.c
  group Middlewares/mini_json
    ../third_party/mini_json/: mini_json.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_qspi.c
