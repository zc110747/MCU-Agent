# Keil uVision project stm32f429_tinyusb_ui.uvprojx, settings and files
target stm32f429_tinyusb_ui (6140000::V6.14::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CLOCK(25000000) CPUTYPE("Cortex-M4") ELITTLE FPU2
  output: stm32f429_tinyusb_ui +hex
  AfterMake: fromelf --bin !L --output .\Objects\stm32f429_tinyusb_ui.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F429xx,USE_HAL_DRIVER,CFG_TUSB_MCU=OPT_MCU_STM32F4,CFG_TUSB_OS=OPT_OS_FREERTOS,PRINT_LOG_ENABLE=1
  c include: ..\app;..\app\ui;..\bsp;..\sys_startup;..\Drivers\CMSIS\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\third_party\FreeRTOS-Kernel\include;..\third_party\FreeRTOS-Kernel\portable\GCC\ARM_CM4F;..\third_party\Fatfs;..\third_party\tinyusb\src;..\third_party\lvgl;..\third_party\lvgl\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0xc0000000 size 0x1000000
  group Startup/MDK-ARM
    ../sys_startup/arm/: startup_stm32f429xx.s
  group Application/User
    ../app/: main.c log.c app_ui.c ui_task.c touch_task.c sensor_task.c sd_card.c sdram_heap.c fs_diskio.c usb_host_app.c stm32f4xx_it.c stm32f4xx_hal_timebase_tim.c
    ./: mdk_target.c
  group Application/User/UI
    ../app/ui/: page_ctrl.c page_hwinfo.c page_rtc.c page_status.c
  group Drivers/BSP
    ../bsp/: bsp_delay.c bsp_led.c bsp_uart.c bsp_i2c.c bsp_pcf8574.c bsp_ap3216.c bsp_mpu9250.c bsp_sw_i2c.c bsp_gt9147.c bsp_touch.c bsp_sdram.c bsp_sdio.c bsp_usb_hw.c bsp_lcd.c bsp_lcd_text.c lcd_ascii_font.c lv_font_gbk.c lv_gbk_map.c lv_port_disp.c lv_port_indev.c bsp_rtc.c bsp_eeprom_24c02.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../sys_startup/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../third_party/FreeRTOS-Kernel/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
    ../third_party/FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c
    ../third_party/FreeRTOS-Kernel/portable/MemMang/: heap_5.c
  group Middlewares/TinyUSB
    ../third_party/tinyusb/src/: tusb.c
    ../third_party/tinyusb/src/host/: usbh.c hub.c
    ../third_party/tinyusb/src/class/msc/: msc_host.c
    ../third_party/tinyusb/src/portable/synopsys/dwc2/: dwc2_common.c hcd_dwc2.c
    ../third_party/tinyusb/src/common/: tusb_fifo.c
  group Middlewares/FatFs
    ../third_party/Fatfs/: ff.c ffunicode.c ffsystem.c
  group Middlewares/LVGL/core
    ../third_party/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middlewares/LVGL/draw
    ../third_party/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group Middlewares/LVGL/draw/arm2d
    ../third_party/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
  group Middlewares/LVGL/draw/nxp
    ../third_party/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../third_party/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
  group Middlewares/LVGL/draw/renesas
    ../third_party/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
  group Middlewares/LVGL/draw/sdl
    ../third_party/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group Middlewares/LVGL/draw/stm32_dma2d
    ../third_party/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group Middlewares/LVGL/draw/sw
    ../third_party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group Middlewares/LVGL/draw/swm341_dma2d
    ../third_party/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
  group Middlewares/LVGL/extra
    ../third_party/lvgl/src/extra/: lv_extra.c
  group Middlewares/LVGL/extra/layouts
    ../third_party/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../third_party/lvgl/src/extra/layouts/grid/: lv_grid.c
  group Middlewares/LVGL/extra/libs
    ../third_party/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../third_party/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../third_party/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../third_party/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../third_party/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../third_party/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../third_party/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../third_party/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../third_party/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../third_party/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
  group Middlewares/LVGL/extra/others
    ../third_party/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../third_party/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../third_party/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../third_party/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../third_party/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../third_party/lvgl/src/extra/others/msg/: lv_msg.c
    ../third_party/lvgl/src/extra/others/snapshot/: lv_snapshot.c
  group Middlewares/LVGL/extra/themes
    ../third_party/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../third_party/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../third_party/lvgl/src/extra/themes/mono/: lv_theme_mono.c
  group Middlewares/LVGL/extra/widgets
    ../third_party/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../third_party/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../third_party/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../third_party/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../third_party/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../third_party/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../third_party/lvgl/src/extra/widgets/led/: lv_led.c
    ../third_party/lvgl/src/extra/widgets/list/: lv_list.c
    ../third_party/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../third_party/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../third_party/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../third_party/lvgl/src/extra/widgets/span/: lv_span.c
    ../third_party/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../third_party/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../third_party/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../third_party/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../third_party/lvgl/src/extra/widgets/win/: lv_win.c
  group Middlewares/LVGL/font
    ../third_party/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group Middlewares/LVGL/hal
    ../third_party/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middlewares/LVGL/misc
    ../third_party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middlewares/LVGL/widgets
    ../third_party/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
