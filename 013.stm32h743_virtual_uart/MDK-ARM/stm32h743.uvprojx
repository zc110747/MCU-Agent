# Keil uVision project stm32h743.uvprojx, settings and files
target debug (6140000::V6.14::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: stm32h743 +hex
  AfterMake: fromelf --bincombined --output Objects\debug\stm32h743.bin !L
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=5 wLevel=1
  c define: STM32H743xx,USE_HAL_DRIVER
  c misc: -Wno-unused-parameter -Wno-sign-compare
  c include: ..\app;..\bsp;..\bsp\sw_uart;..\tools;..\sys_startup;..\Drivers\CMSIS\Core\Include;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: stm32h743.sct
  link misc: --diag_suppress=L6314W
  group Application/Startup
    ../sys_startup/: system_stm32h7xx.c
    ./: startup_stm32h743xx.s
  group Application/User
    ../app/: main.c
    ../bsp/: bsp.c stm32h7xx_it.c
    ./: mdk_target.c
  group Software UART
    ../bsp/sw_uart/: sw_uart.c sw_uart_gpio.c sw_uart_timer.c sw_uart_dma.c sw_uart_tx.c sw_uart_rx.c
  group Tools/Acceptance
    ../tools/: tx_selftest.c phase3_test.c rx_test.c echo_test.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
target release (6140000::V6.14::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: as above
  output: stm32h743 +hex
  AfterMake: fromelf --bincombined --output Objects\release\stm32h743.bin !L
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=5 wLevel=1
  c define: STM32H743xx,USE_HAL_DRIVER
  c misc: -Wno-unused-parameter -Wno-sign-compare
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: stm32h743.sct
  link misc: --diag_suppress=L6314W
