# Keil uVision project stm32h743.uvprojx, settings and files
target debug (6140000::V6.14::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: stm32h743 +hex
  AfterMake: fromelf --bincombined --output Objects\debug\stm32h743.bin !L
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=5 wLevel=1
  c define: STM32H743xx,USE_HAL_DRIVER,CFG_TUSB_MCU=OPT_MCU_STM32H7,CFG_TUSB_OS=OPT_OS_NONE,BOARD_TUD_RHPORT=0
  c misc: -Wno-unused-parameter -Wno-sign-compare
  c include: ..\app;..\bsp;..\bsp\camera;..\mouse;..\usb;..\protocol;..\algorithms;..\sys_startup;..\third_party\tinyusb\src;..\Drivers\CMSIS\Core\Include;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy
  asm define: as above
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: stm32h743.sct
  link misc: --diag_suppress=L6314W
  group Application/Startup
    ../sys_startup/: system_stm32h7xx.c
    ../sys_startup/arm/: startup_stm32h743xx.s
  group Application/User
    ../app/: main.c
    ./: mdk_target.c
  group Bsp
    ../bsp/: bsp.c bsp_button.c bsp_uart.c bsp_camera.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Bsp/Camera
    ../bsp/camera/: ov5640.c ov5640_reg.c
    ../bsp/: bsp_ov5640_ref.c
  group Mouse
    ../mouse/: mouse_input.c mouse_core.c mouse_report.c
  group Protocol
    ../protocol/: uart_protocol.c command_handler.c
  group Usb
    ../usb/: usb_descriptors.c usb_hid_mouse.c
  group Algorithms
    ../algorithms/: image_motion.c motion_filter.c
  group Middlewares/TinyUSB
    ../third_party/tinyusb/src/: tusb.c
    ../third_party/tinyusb/src/common/: tusb_fifo.c
    ../third_party/tinyusb/src/device/: usbd.c
    ../third_party/tinyusb/src/class/hid/: hid_device.c
    ../third_party/tinyusb/src/portable/synopsys/dwc2/: dcd_dwc2.c dwc2_common.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_dcmi.c
target release (6140000::V6.14::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: as above
  output: stm32h743 +hex
  AfterMake: fromelf --bincombined --output Objects\release\stm32h743.bin !L
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=5 wLevel=1
  c define: as above
  c misc: -Wno-unused-parameter -Wno-sign-compare
  c include: as above
  asm define: as above
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: stm32h743.sct
  link misc: --diag_suppress=L6314W
