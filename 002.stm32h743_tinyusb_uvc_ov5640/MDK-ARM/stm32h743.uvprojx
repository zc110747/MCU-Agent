# Keil uVision project stm32h743.uvprojx, settings and files
target stm32h743 (6140000::V6.14::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: stm32h743 +hex
  AfterMake: fromelf --bin !L --output Objects\stm32h743.bin
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32H743xx,USE_HAL_DRIVER,USE_PWR_LDO_SUPPLY,HSE_VALUE=25000000,CFG_TUSB_MCU=OPT_MCU_STM32H7,CFG_TUSB_OS=OPT_OS_NONE,BOARD_TUD_RHPORT=0,BOARD_TUD_MAX_SPEED=OPT_MODE_FULL_SPEED
  c misc: -Wno-unused-parameter -Wno-sign-compare
  c include: ..\app;..\bsp;..\bsp\ov5640;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\sys_startup;..\third_party\tinyusb\src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/Startup
    ../sys_startup/arm/: startup_stm32h743xx.s
    ../sys_startup/: system_stm32h7xx.c
  group Application/User
    ../app/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c uvc_app.c
    ./: mdk_target.c
  group bsp
    ../bsp/: bsp_board.c bsp_camera.c bsp_ov5640_ref.c usb_descriptors.c sys_prob.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group bsp/ov5640
    ../bsp/ov5640/: ov5640.c ov5640_reg.c
  group Middlewares/TinyUSB
    ../third_party/tinyusb/src/: tusb.c
    ../third_party/tinyusb/src/common/: tusb_fifo.c
    ../third_party/tinyusb/src/device/: usbd.c
    ../third_party/tinyusb/src/class/video/: video_device.c
    ../third_party/tinyusb/src/portable/synopsys/dwc2/: dcd_dwc2.c dwc2_common.c
