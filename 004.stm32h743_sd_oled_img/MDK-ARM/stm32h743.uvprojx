# Keil uVision project stm32h743.uvprojx, settings and files
target stm32h743 (6140000::V6.14::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: stm32h743 +hex
  AfterMake: fromelf --bin !L --output Objects\stm32h743.bin
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32H743xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER
  c misc: -Wno-unused-parameter -Wno-sign-compare -fno-strict-aliasing
  c include: ..\Core\Inc;..\bsp;..\app;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\sys_startup;..\Drivers\CMSIS\Include;..\third_party\FatFs;..\third_party\tjpgd
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: stm32h743.sct
  group Application/Startup
    ../sys_startup/: system_stm32h7xx.c
    ./: startup_stm32h743xx.s
  group Core/Src
    ../Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
    ./: mdk_target.c
  group bsp
    ../bsp/: bsp_log.c bsp_oled.c disk_interface.c drv_oled_fonts.c drv_oled_text.c drv_sdio.c drv_spi_oled.c
  group app
    ../app/: app_image.c app_slideshow.c
  group Middlewares/FatFs
    ../third_party/FatFs/: diskio.c ff.c ffsystem.c ffunicode.c
  group Middlewares/tjpgd
    ../third_party/tjpgd/: tjpgd.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_sd.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_spi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
